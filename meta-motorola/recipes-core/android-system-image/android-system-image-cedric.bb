require recipes-core/android-system-image/android-system-image.inc

COMPATIBLE_MACHINE = "cedric"

PV = "20180914-22"

SRC_URI = "file://halium-luneos-7.1-20200203-1-cedric-dbg.tar.bz2"
SRC_URI[md5sum] = "f6c7349b6e2375c274a0b590205d11f9"
SRC_URI[sha256sum] = "b6a8d0afea7107c6e18be943c8724b2b1153b6532d8c71d1b298ecccceca53e6"
